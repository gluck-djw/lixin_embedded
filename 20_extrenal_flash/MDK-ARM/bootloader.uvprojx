# Keil uVision project bootloader.uvprojx, settings and files
target std_lib_project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F411xE
  c include: ..\Core\Inc;..\Drivers\CMSIS\Inc;..\Drivers\STM32F4xx_StdPeriph_Diver\inc;..\Middlewares\easylogger\inc;..\Middlewares\easylogger\plugins\file;..\Middlewares\easylogger\plugins\flash;..\Middlewares\RTT;..\Middlewares\ymodem;..\Core\Inc;..\Algorithm;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group BSP
    ../BSP/: w25qxx.c
  group Core
    ../Core/Src/: main.c stm32f4xx_it.c system_stm32f4xx.c flash.c usart.c gpio.c spi.c w25qxx_handle.c
  group Drivers
    ../Drivers/STM32F4xx_StdPeriph_Diver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    ../Drivers/CMSIS/: startup_stm32f411xe.s
  group Middlewares/Easylogger
    ../Middlewares/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
    ../Middlewares/easylogger/port/: elog_port.c
    ../Middlewares/easylogger/plugins/flash/: elog_flash_port.c
    ../Middlewares/easylogger/plugins/file/: elog_file.c elog_file_port.c
  group Middlewares/RTT
    ../Middlewares/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group Middlewares/Ymodem
    ../Middlewares/ymodem/: ymodem.c common.c
  group Algorithm
    ../Algorithm/: aes.c
