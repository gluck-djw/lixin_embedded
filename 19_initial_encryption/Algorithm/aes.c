#include <stdint.h>
#include <string.h>
#include <stdio.h>
#include <stdbool.h>
#include <stdint.h>
#include "aes.h"

/* 加密轮次 */
#if AES_KEY_SIZE == 128
#define Nr 10
#elif AES_KEY_SIZE == 192
#define Nr 12
#elif AES_KEY_SIZE == 256
#define Nr 14
#else
#error "AES_KEY_SIZE must be one of 128, 192, or 256"
#endif

#define Nk (AES_KEY_SIZE / 32) // 密钥字数（以32位字为单位）
#define Nb 4                 // 列数

static unsigned char g_roundKeyTable[4 * Nb * (Nr + 1)]; // 轮密钥表(bit)

static const unsigned char sbox[256] = {
    0x63, 0x7c, 0x77, 0x7b, 0xf2, 0x6b, 0x6f, 0xc5, 0x30, 0x01, 0x67, 0x2b, 0xfe, 0xd7, 0xab, 0x76,
    0xca, 0x82, 0xc9, 0x7d, 0xfa, 0x59, 0x47, 0xf0, 0xad, 0xd4, 0xa2, 0xaf, 0x9c, 0xa4, 0x72, 0xc0,
    0xb7, 0xfd, 0x93, 0x26, 0x36, 0x3f, 0xf7, 0xcc, 0x34, 0xa5, 0xe5, 0xf1, 0x71, 0xd8, 0x31, 0x15,
    0x04, 0xc7, 0x23, 0xc3, 0x18, 0x96, 0x05, 0x9a, 0x07, 0x12, 0x80, 0xe2, 0xeb, 0x27, 0xb2, 0x75,
    0x09, 0x83, 0x2c, 0x1a, 0x1b, 0x6e, 0x5a, 0xa0, 0x52, 0x3b, 0xd6, 0xb3, 0x29, 0xe3, 0x2f, 0x84,
    0x53, 0xd1, 0x00, 0xed, 0x20, 0xfc, 0xb1, 0x5b, 0x6a, 0xcb, 0xbe, 0x39, 0x4a, 0x4c, 0x58, 0xcf,
    0xd0, 0xef, 0xaa, 0xfb, 0x43, 0x4d, 0x33, 0x85, 0x45, 0xf9, 0x02, 0x7f, 0x50, 0x3c, 0x9f, 0xa8,
    0x51, 0xa3, 0x40, 0x8f, 0x92, 0x9d, 0x38, 0xf5, 0xbc, 0xb6, 0xda, 0x21, 0x10, 0xff, 0xf3, 0xd2,
    0xcd, 0x0c, 0x13, 0xec, 0x5f, 0x97, 0x44, 0x17, 0xc4, 0xa7, 0x7e, 0x3d, 0x64, 0x5d, 0x19, 0x73,
    0x60, 0x81, 0x4f, 0xdc, 0x22, 0x2a, 0x90, 0x88, 0x46, 0xee, 0xb8, 0x14, 0xde, 0x5e, 0x0b, 0xdb,
    0xe0, 0x32, 0x3a, 0x0a, 0x49, 0x06, 0x24, 0x5c, 0xc2, 0xd3, 0xac, 0x62, 0x91, 0x95, 0xe4, 0x79,
    0xe7, 0xc8, 0x37, 0x6d, 0x8d, 0xd5, 0x4e, 0xa9, 0x6c, 0x56, 0xf4, 0xea, 0x65, 0x7a, 0xae, 0x08,
    0xba, 0x78, 0x25, 0x2e, 0x1c, 0xa6, 0xb4, 0xc6, 0xe8, 0xdd, 0x74, 0x1f, 0x4b, 0xbd, 0x8b, 0x8a,
    0x70, 0x3e, 0xb5, 0x66, 0x48, 0x03, 0xf6, 0x0e, 0x61, 0x35, 0x57, 0xb9, 0x86, 0xc1, 0x1d, 0x9e,
    0xe1, 0xf8, 0x98, 0x11, 0x69, 0xd9, 0x8e, 0x94, 0x9b, 0x1e, 0x87, 0xe9, 0xce, 0x55, 0x28, 0xdf,
    0x8c, 0xa1, 0x89, 0x0d, 0xbf, 0xe6, 0x42, 0x68, 0x41, 0x99, 0x2d, 0x0f, 0xb0, 0x54, 0xbb, 0x16};

static const unsigned char sbox_inv[256] = {
    0x52, 0x09, 0x6a, 0xd5, 0x30, 0x36, 0xa5, 0x38, 0xbf, 0x40, 0xa3, 0x9e, 0x81, 0xf3, 0xd7, 0xfb,
    0x7c, 0xe3, 0x39, 0x82, 0x9b, 0x2f, 0xff, 0x87, 0x34, 0x8e, 0x43, 0x44, 0xc4, 0xde, 0xe9, 0xcb, 0x54, 0x7b, 0x94, 0x32, 0xa6, 0xc2, 0x23, 0x3d, 0xee, 0x4c, 0x95, 0x0b, 0x42, 0xfa, 0xc3, 0x4e, 0x08, 0x2e, 0xa1, 0x66, 0x28, 0xd9, 0x24, 0xb2, 0x76, 0x5b, 0xa2, 0x49, 0x6d, 0x8b, 0xd1, 0x25, 0x72, 0xf8, 0xf6, 0x64, 0x86, 0x68, 0x98, 0x16, 0xd4, 0xa4, 0x5c, 0xcc, 0x5d, 0x65, 0xb6, 0x92, 0x6c, 0x70, 0x48, 0x50, 0xfd, 0xed, 0xb9, 0xda, 0x5e, 0x15, 0x46, 0x57, 0xa7, 0x8d, 0x9d, 0x84, 0x90, 0xd8, 0xab, 0x00, 0x8c, 0xbc, 0xd3, 0x0a, 0xf7, 0xe4, 0x58, 0x05, 0xb8, 0xb3, 0x45, 0x06, 0xd0, 0x2c, 0x1e, 0x8f, 0xca, 0x3f, 0x0f, 0x02, 0xc1, 0xaf, 0xbd, 0x03, 0x01, 0x13, 0x8a, 0x6b, 0x3a, 0x91, 0x11, 0x41, 0x4f, 0x67, 0xdc, 0xea, 0x97, 0xf2, 0xcf, 0xce, 0xf0, 0xb4, 0xe6, 0x73, 0x96, 0xac, 0x74, 0x22, 0xe7, 0xad, 0x35, 0x85, 0xe2, 0xf9, 0x37, 0xe8, 0x1c, 0x75, 0xdf, 0x6e, 0x47, 0xf1, 0x1a, 0x71, 0x1d, 0x29, 0xc5, 0x89, 0x6f, 0xb7, 0x62, 0x0e, 0xaa, 0x18, 0xbe, 0x1b, 0xfc, 0x56, 0x3e, 0x4b, 0xc6, 0xd2, 0x79, 0x20, 0x9a, 0xdb, 0xc0, 0xfe, 0x78, 0xcd, 0x5a, 0xf4, 0x1f, 0xdd, 0xa8, 0x33, 0x88, 0x07, 0xc7, 0x31, 0xb1, 0x12, 0x10, 0x59, 0x27, 0x80, 0xec, 0x5f, 0x60, 0x51, 0x7f, 0xa9, 0x19, 0xb5, 0x4a, 0x0d, 0x2d, 0xe5, 0x7a, 0x9f, 0x93, 0xc9, 0x9c, 0xef, 0xa0, 0xe0, 0x3b, 0x4d, 0xae, 0x2a, 0xf5, 0xb0, 0xc8, 0xeb, 0xbb, 0x3c, 0x83, 0x53, 0x99, 0x61, 0x17, 0x2b, 0x04, 0x7e, 0xba, 0x77, 0xd6, 0x26, 0xe1, 0x69, 0x14, 0x63, 0x55, 0x21, 0x00, 0x7d};

#define BPOLY 0x1B // irreducible polynomial m(x) = x^8 + x^4 + x^3 + x + 1

/* 比函数形式节省4字节的data数据 */
#define AddRoundKey(state, pround_key) \
    xor_bytes(state, pround_key, 4 * Nb)

/*  将一个字中的4个字节循环左移一个字节 */
void rotation_word(unsigned char *word)
{
    unsigned char temp = word[0];
    word[0] = word[1];
    word[1] = word[2];
    word[2] = word[3];
    word[3] = temp;
}

void xor_bytes(unsigned char *word1, unsigned char *word2, unsigned char nCount)
{
    unsigned char i;
    for (i = 0; i < nCount; i++)
    {
        word1[i] ^= word2[i];
    }
}

/* 用s盒子置换状态数据 */
static void sub_bytes(unsigned char *word, unsigned char nCount, bool bInvert)
{
    unsigned char i;
    const unsigned char *pSBox = bInvert ? sbox_inv : sbox; // 根据是否需要解密选择s盒
    for (i = 0; i < nCount; i++)
    {
        word[i] = pSBox[word[i]];
    }
}

// /* GF（2^8）有限域乘法 */
uint8_t gmult(uint8_t a, uint8_t b)
{
    uint8_t i, p = 0, hbs = 0;
    for (i = 0; i < 8; i++)
    {
        if (b & 1)
        {
            p ^= a;
        }
        hbs = a & 0x80;
        a <<= 1; // 左移是因为我们从 b 的最低位开始往上处理，位权是 2⁰→2¹→2²→…，每往高走一位

        if (hbs)
        {
            a = a ^ BPOLY; // 溢出 → 模 m(x) 约减，异或 0x1B
        }
        b >>= 1; // 右移是保证最低位是当前计算位
    }
    return p;
}

// unsigned char Rcon[4] = {0x01, 0x00, 0x00, 0x00}; // 轮常量
// /* RC[i] = x^(i-1)，每一项是上一项在 GF(2⁸) 里乘 2 */
// uint8_t *R(uint8_t i)
// {
//     if (i == 1)
//     {
//         Rcon[0] = 0x01;
//     }
//     else if (i > 1)
//     {
//         Rcon[0] = 0x02;
//         i--;
//         while (i > 1)
//         {
//             Rcon[0] = gmult(Rcon[0], 0x02);
//             i--;
//         }
//     }
// }

unsigned char gf_mult(unsigned char num)
{
    if ((num & 0x80) == 0)
    {
        num = num << 1;
    }
    else
    {
        num = (num << 1) ^ 0x1b;
    }
    return num;
}

/* 第一行不变， 第二行左移1字节， 第三行左移2字节， 第四行左移3字节
shift(1,4)=1; shift(2,4)=2; shift(3,4)=3 */

void shift_rows(unsigned char *word, bool bInvert)
{
    unsigned char temp;
    unsigned char rowdata[Nb];
    unsigned char i, j;
    for (i = 1; i < 4; i++) /* 第1~3行，第0行不动 */
    {
        for (j = 0; j < Nb; j++) // 先把第 i 行原始数据存好
        {
            rowdata[j] = word[i + j * Nb];
        }

        temp = bInvert ? (Nb - i) : i; // 逆序时，左移变成右移
        for (j = 0; j < Nb; j++)
        {
            word[i + j * Nb] = rowdata[(temp + j) % Nb];
        }
    }
}

void coefmul(uint8_t *a, uint8_t *b, uint8_t *res)
{
    res[0] = gmult(a[0], b[0]) ^ gmult(a[1], b[1]) ^ gmult(a[2], b[2]) ^ gmult(a[3], b[3]);
    res[1] = gmult(a[3], b[0]) ^ gmult(a[0], b[1]) ^ gmult(a[1], b[2]) ^ gmult(a[2], b[3]);
    res[2] = gmult(a[2], b[0]) ^ gmult(a[3], b[1]) ^ gmult(a[0], b[2]) ^ gmult(a[1], b[3]);
    res[3] = gmult(a[1], b[0]) ^ gmult(a[2], b[1]) ^ gmult(a[3], b[2]) ^ gmult(a[0], b[3]);
}

void mix_columns(uint8_t *word, bool inv)
{
    uint8_t a[] = {0x02, 0x03, 0x01, 0x01};
    uint8_t b[] = {0x0e, 0x0b, 0x0d, 0x09};
    uint8_t i, j, *tmp, col[4], res[4];

    for (j = 0; j < Nb; j++)
    {
        for (i = 0; i < 4; i++)
        {
            col[i] = word[i  + j* Nb];
        }
        tmp = inv ? b : a;
        coefmul(tmp, col, res);

        for (i = 0; i < 4; i++)
        {
            word[i  + j* Nb] = res[i];
        }
    }
}

/* 主密钥 密钥扩展 -> 一串轮密钥 */
void AES_key_expansion(const void *key)
{
    unsigned char i;
    unsigned char *pround_key;

    unsigned char Rcon[4] = {0x01, 0x00, 0x00, 0x00}; // 轮常量
    memcpy(g_roundKeyTable, key, Nk * 4);

    pround_key = &g_roundKeyTable[Nk * 4]; // 指向字节16 = w[4] 的开头

    for (i = Nk; i < Nb * (Nr + 1); pround_key += 4, i++)
    {
        memcpy(pround_key, pround_key - 4, Nk);
        if (i % Nk == 0)
        {
            // 字循环
            rotation_word(pround_key);
            // 字节代换：对字循环后的字节进行字节代换
            sub_bytes(pround_key, 4, false);
            // 轮常量异或
            xor_bytes(pround_key, Rcon, 4);
            Rcon[0] = gf_mult(Rcon[0]);
        }
        else if (Nk > 6 && i % Nk == 4) // 仅 AES-256
        {
            sub_bytes(pround_key, 4, false); // 只过 S 盒，不旋转、不加
        }
        xor_bytes(pround_key, pround_key - Nk * 4, 4);
    }
}

/* 对单块数据加密 */
static void block_encrypt(unsigned char *pState)
{
    AddRoundKey(pState, g_roundKeyTable);
    for (int i = 1; i <= Nr; i++)
    {
        // 字节代换
        sub_bytes(pState, 4 * Nb, false);
        // 行移位
        shift_rows(pState, false);
        if (i != Nr)
        {
            // 列混合
            mix_columns(pState, false);
        }

        // 轮密钥加
        AddRoundKey(pState, g_roundKeyTable + i * 4 * Nb);
    }
}

/* 对单块数据解密 */
static void block_decrypt(unsigned char *pState)
{
    AddRoundKey(pState, g_roundKeyTable + Nr * 4 * Nb);
    for (int i = Nr; i > 0; i--)
    {
        shift_rows(pState, true);
        sub_bytes(pState, 4 * Nb, true);

        AddRoundKey(pState, g_roundKeyTable + (i - 1) * 4 * Nb);
        if (i != 1)
        {
            mix_columns(pState, true);
        }
    }
}

/* 加密数据 */
void AES_encrypt(unsigned char *pPlaintext, unsigned char *pCipherText, unsigned int nDataLen, unsigned char *pIV)
{
    unsigned char i;
    if (pPlaintext != pCipherText)
    {
        memcpy(pCipherText, pPlaintext, nDataLen);
    }
    for (i = nDataLen / (4 * Nb); i > 0; i--, pCipherText += 4 * Nb)
    {
#if AES_MODE == CBC
        xor_bytes(pCipherText, pIV, 4 * Nb);
#endif
        block_encrypt(pCipherText);
        pIV = pCipherText;
    }
}

/* 解密数据 */
void AES_decrypt(unsigned char *pCipherText, unsigned char *pPlaintext, unsigned int nDataLen, unsigned char *pIV)
{
    unsigned char i;
    if (pPlaintext != pCipherText)
    {
        memcpy(pPlaintext, pCipherText, nDataLen);
    }
    // 从最后一块数据开始解密
    pPlaintext += nDataLen - 4 * Nb;
    for (i = nDataLen / (4 * Nb); i > 0; i--, pPlaintext -= 4 * Nb)
    {
        block_decrypt(pPlaintext);
#if AES_MODE == CBC
        if (i == 1) // 最后一块
        {
            xor_bytes(pPlaintext, pIV, 4 * Nb);
        }
        else
        {
            xor_bytes(pPlaintext, pPlaintext - 4 * Nb, 4 * Nb);
        }
#endif
    }
}
